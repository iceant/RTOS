# Keil uVision project UB_GD32F470VGT6.uvprojx, settings and files
target UB_GD32F470VGT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UB_GD32F470VGT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F470,USE_STDPERIPH_DRIVER,HXTAL_VALUE=12000000,NDEBUG
  c include: ..\cmake-build-debug\_deps\gd32f4xx_firmware_library-src\Firmware\CMSIS\;..\cmake-build-debug\_deps\gd32f4xx_firmware_library-src\Firmware\CMSIS\GD\GD32F4xx\Include\;..\cmake-build-debug\_deps\gd32f4xx_firmware_library-src\Firmware\GD32F4xx_standard_peripheral\Include\;..\..\..\CPU\ARM_CortexM4\;..\..\..\CPU\ARM_CortexM4\ARMCC\;..\..\..\Compiler\ARMCC\;..\..\..\Kernel\;..\..\..\SDK\;..\Application\;..\Board\;..\Devices\A7670C\;..\Devices\A7670C\Common\;..\Devices\A7670C\HTTP\;..\Devices\A7670C\InternetService\;..\Devices\A7670C\MQTT\;..\Devices\A7670C\Network\;..\Devices\A7670C\PacketDomain\;..\Devices\A7670C\SIMCard\;..\Devices\A7670C\StatusControl\;..\Devices\A7670C\V25TER\;..\Devices\DS1307\;..\Devices\OLED\;..\Devices\SDCard\;..\Devices\SPIFlash\;..\cmake-build-debug\_deps\tlsf-src-src\src\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../cmake-build-debug/_deps/gd32f4xx_firmware_library-src/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group FWLIB
    ../cmake-build-debug/_deps/gd32f4xx_firmware_library-src/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group RTOS_KERNEL
    ../../../Kernel/: os_definitions.c os_errors.c os_idle.c os_interrupt.c os_kernel.c os_list.c os_macros.c os_memory.c os_mutex.c os_priority.c os_scheduler.c os_semaphore.c os_thread.c os_tick.c os_timer.c os_types.c
  group RTOS_CPU
    ../../../CPU/ARM_CortexM4/: cpu.c cpu_atomic.c cpu_interrupt.c cpu_lock.c cpu_registers.c cpu_spinlock.c cpu_stack.c cpu_types.c
    ../../../CPU/ARM_CortexM4/ARMCC/: cpu_functions.c cpu_hardfault.c cpu_pendsv.c cpu_svc.c
  group RTOS_COMPILER
    ../../../Compiler/ARMCC/: rtos_compiler.c
  group Application
    ../Application/: gd32f4xx_it.c main.c system_gd32f4xx.c task_timesync.c use_usart0.c
  group Board
    ../Board/: board.c bsp_can0.c bsp_can1.c bsp_i2c0.c bsp_i2c1.c bsp_led1.c bsp_led2.c bsp_led3.c bsp_led4.c bsp_rs4851.c bsp_rs4852.c bsp_rs4853.c bsp_spi0.c bsp_usart0.c bsp_usart1.c
  group Device_A7670C
    ../Devices/A7670C/: A7670C.c
    ../Devices/A7670C/Common/: A7670C_Common.c
    ../Devices/A7670C/HTTP/: HTTPACTION.c HTTPDATA.c HTTPHEAD.c HTTPINIT.c HTTPPARA.c HTTPREAD.c HTTPTERM.c
    ../Devices/A7670C/InternetService/: CNTP.c
    ../Devices/A7670C/MQTT/: A7670C_MQTT.c CMQTTACCQ.c CMQTTCFG.c CMQTTCONNECT.c CMQTTDISC.c CMQTTPAYLOAD.c CMQTTPUB.c CMQTTREL.c CMQTTSSLCFG.c CMQTTSTART.c CMQTTSTOP.c CMQTTSUB.c CMQTTSUBTOPIC.c CMQTTTOPIC.c CMQTTUNSUB.c CMQTTUNSUBTOPIC.c CMQTTWILLMSG.c CMQTTWILLTOPIC.c
    ../Devices/A7670C/Network/: CPSI.c CREG.c
    ../Devices/A7670C/PacketDomain/: CEREG.c CGACT.c CGDCONT.c CGREG.c
    ../Devices/A7670C/SIMCard/: CPIN.c ICCID.c
    ../Devices/A7670C/StatusControl/: CCLK.c CSQ.c SIMEI.c
    ../Devices/A7670C/V25TER/: ATE.c ATI.c
  group Device_DS1307
    ../Devices/DS1307/: DS1307.c
  group Device_SDCARD
    ../Devices/SDCard/: sdcard.c
  group Device_OLED
    ../Devices/OLED/: OLED.c
  group Device_SPIFlash
    ../Devices/SPIFlash/: spi_flash.c
  group SDK
    ../../../SDK/: md5.c sdk_array.c sdk_bit.c sdk_crc16.c sdk_fmt.c sdk_hex.c sdk_mp.c sdk_ptrbag.c sdk_ring.c sdk_ringbuffer.c sdk_xp.c
  group TLSF
    ../cmake-build-debug/_deps/tlsf-src-src/src/: tlsf.c
